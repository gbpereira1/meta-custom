IMAGE_INSTALL:append = " static-ip myuser"