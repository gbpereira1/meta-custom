IMAGE_INSTALL += " \
    static-ip  \
    mainuser \
"
